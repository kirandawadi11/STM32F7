# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
software components: CMSIS:CORE 5.0.2, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:LTDC 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0
